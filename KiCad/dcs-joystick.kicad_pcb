# Repository Dawson206/dcs-32input-buttonbox

## KiCad design KiCad/dcs-joystick.kicad_pcb

Parts:
J1: Inputs 1-8; TerminalBlock_Phoenix_MPT-0,5-10-2.54_1x10_P2.54mm_Horizont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
J2: Inputs 17-24; TerminalBlock_Phoenix_MPT-0,5-8-2.54_1x08_P2.54mm_Horizontal
J3: Inputs 9-16; TerminalBlock_Phoenix_MPT-0,5-8-2.54_1x08_P2.54mm_Horizontal
J4: Inputs 25-32; TerminalBlock_Phoenix_MPT-0,5-8-2.54_1x08_P2.54mm_Horizontal
RN1, RN2, RN3, RN4: 10K; R_Array_SIP9
U1, U2, U3, U4: 74HC165; DIP-16_W7.62mm
U5: ProMicro

Connections:
9-16: U1.10 (DS), U3.9 (Q7)
17-24: U2.9 (Q7), U3.10 (DS)
25-32: U2.10 (DS), U4.9 (Q7)
+5V: RN1.1 (common), RN2.1 (common), RN3.1 (common), RN4.1 (common), U1.16 (VCC), U2.16 (VCC), U3.16 (VCC), U4.16 (VCC), U5.24 (RAW)
/D0_0: J1.1, RN1.2 (R1), U1.11 (D0)
/D0_1: J3.1, RN3.2 (R1), U3.11 (D0)
/D0_2: J2.1, RN2.2 (R1), U2.11 (D0)
/D0_3: J4.1, RN4.2 (R1), U4.11 (D0)
/D1_0: J1.2, RN1.3 (R2), U1.12 (D1)
/D1_1: J3.2, RN3.3 (R2), U3.12 (D1)
/D1_2: J2.2, RN2.3 (R2), U2.12 (D1)
/D1_3: J4.2, RN4.3 (R2), U4.12 (D1)
/D2_0: J1.3, RN1.4 (R3), U1.13 (D2)
/D2_1: J3.3, RN3.4 (R3), U3.13 (D2)
/D2_2: J2.3, RN2.4 (R3), U2.13 (D2)
/D2_3: J4.3, RN4.4 (R3), U4.13 (D2)
/D3_0: J1.4, RN1.5 (R4), U1.14 (D3)
/D3_1: J3.4, RN3.5 (R4), U3.14 (D3)
/D3_2: J2.4, RN2.5 (R4), U2.14 (D3)
/D3_3: J4.4, RN4.5 (R4), U4.14 (D3)
/D4_0: J1.5, RN1.6 (R5), U1.3 (D4)
/D4_1: J3.5, RN3.6 (R5), U3.3 (D4)
/D4_2: J2.5, RN2.6 (R5), U2.3 (D4)
/D4_3: J4.5, RN4.6 (R5), U4.3 (D4)
/D5_0: J1.6, RN1.7 (R6), U1.4 (D5)
/D5_1: J3.6, RN3.7 (R6), U3.4 (D5)
/D5_2: J2.6, RN2.7 (R6), U2.4 (D5)
/D5_3: J4.6, RN4.7 (R6), U4.4 (D5)
/D6_0: J1.7, RN1.8 (R7), U1.5 (D6)
/D6_1: J3.7, RN3.8 (R7), U3.5 (D6)
/D6_2: J2.7, RN2.8 (R7), U2.5 (D6)
/D6_3: J4.7, RN4.8 (R7), U4.5 (D6)
/D7_0: J1.8, RN1.9 (R8), U1.6 (D7)
/D7_1: J3.8, RN3.9 (R8), U3.6 (D7)
/D7_2: J2.8, RN2.9 (R8), U2.6 (D7)
/D7_3: J4.8, RN4.9 (R8), U4.6 (D7)
GNDREF: J1.9, J1.10, U1.8 (GND), U1.15 (~CE), U2.8 (GND), U2.15 (~CE), U3.8 (GND), U3.15 (~CE), U4.8 (GND), U4.15 (~CE), U5.3 (GND), U5.4 (GND), U5.23 (GND)
LOAD: U1.1 (~PL), U2.1 (~PL), U3.1 (~PL), U4.1 (~PL), U5.10 (7)
MISO: U1.7 (~Q7), U5.15 (14)
SCLK: U1.2 (CP), U2.2 (CP), U3.2 (CP), U4.2 (CP), U5.16 (15)

Notes on the sheet:
Inputs 25-32
Inputs 9-16
Inputs 1-8
Arduino Pro Micro
Inputs 17-24

Board: 2 copper layers, 59.7 x 69.8 mm, 15 parts (0 on the bottom side), 40 nets.

Other parts of the board:
2xPCB, 2xPCB#2: Alignment_Pin

## Commit log

2022-01-27 Add dcs-joystick.cpp.
2022-01-27 Fix buttons 17-32 being read as button 16.
2022-01-27 Add KiCad project.
2022-01-27 Rename dcs-joystick.cpp to dcs-joystick.ino.
2022-02-12 Fix design errors on PCB.
2022-02-13 Add button debounce logic for all 32 inputs.
2022-02-13 Use braces around bounce_last_change init.
2022-02-13 Set debounce time to 50 ms.
2022-02-14 Fix millis() overflow in button de-bounce logic.
